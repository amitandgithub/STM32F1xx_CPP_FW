<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Main.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Users\amitchaudhar\Desktop\test_RC\test_rc.ewp</path>
    </project>
    <batchBuild />
</workspace>
