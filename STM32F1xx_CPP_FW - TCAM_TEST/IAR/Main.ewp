# IAR project Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; USE_FULL_LL_DRIVER; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\App\Inc; ..; ..\Test\inc; ..\Utils\inc; ..\HAL\Common; ..\Drivers\CMSIS\Include; ..\HW_Modules\HwButton; ..\HAL\I2C; ..\HW_Modules\BMP280; ..\SW_Modules\DebugLog; ..\HAL\DMA; ..\HW_Modules\DS1307_RTC; ..\SW_Modules\CmdSvr; ..\SW_Modules\CmdSvr\I2C_CMD; ..\HW_Modules\Oled; ..\HAL\Gpio\DigitalIO; ..\HW_Modules\INA219; ..\HW_Modules\MLX90615; ..\HAL\RTC; ..\HW_Modules\Nokia_5110; ..\HAL\SPI; ..\HW_Modules\w25qxx; ..\HW_Modules\TFT\ST7735; ..\HAL\Gpio\Gpio; ..\HAL\USB Device; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\HW_Modules\ST77xx; ..\HW_Modules\HwButton; ..\SW_Modules\UI; ..\HW_Modules\SD\inc; ..\HAL\UART; ..\HAL\ADC; ..\HAL\Irda; ..\HAL\Timers; ..\HW_Modules\IR; ..\SW_Modules\Printf; ..\Startup; ..\Drivers\Inc; ..\Drivers\CMSIS; ..\App\Src; ..\HAL\Flash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Main.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../App/Src/: main.cpp PowerMonitor.cpp
  group Drivers
    ../Drivers/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
  group HAL/ADC
    ../HAL/ADC/: ADC.cpp ADC_test.h AnalogIn.h
  group HAL/Common
    ../HAL/Common/: CPP_HAL.cpp HAL_Objects.h InterruptHandlers.cpp InterruptManager.cpp
  group HAL/DigitalIO
    ../HAL/Gpio/DigitalIO/: DigitalIn.h DigitalInOut.h DigitalIO.cpp DigitalOut.h
  group HAL/DMA
    ../HAL/DMA/: DMA.cpp
  group HAL/Flash
    ../HAL/Flash/: FlASH_PAGE.c
    ../Drivers/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group HAL/Gpio
    ../HAL/Gpio/Gpio/: GpioOutput.cpp
  group HAL/I2C
    ../HAL/I2C/: I2c.cpp I2C_Test.cpp
  group HAL/Irda
    ../HAL/Irda/: IrDecoder.h IrEncoder.h
  group HAL/RTC
    ../HAL/RTC/: RTC.cpp
  group HAL/SPI
    ../HAL/SPI/: Spi.cpp
  group HAL/Timers
    ../HAL/Timers/: Gpt.h PulseIn.h PulseOut.h
  group HAL/UART
    ../HAL/UART/: Uart.cpp
  group HAL/USB
    ../Drivers/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
    ../HAL/USB Device/: usb_device.c usbd_cdc.c usbd_cdc_if.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group HW_Modules/BMP280
    ../HW_Modules/BMP280/: BMP280.cpp
  group HW_Modules/Button
    ../HW_Modules/HwButton/: BtnInt.cpp BtnPoll.cpp
  group HW_Modules/INA219
    ../HW_Modules/INA219/: INA219.cpp
  group HW_Modules/IR
    ../HW_Modules/IR/: ir_Aiwa.c ir_Denon.c ir_Dish.c ir_JVC.c ir_LG.c ir_Mitsubishi.c ir_NEC.c ir_Panasonic.c ir_RC5_RC6.c ir_Samsung.c ir_Sanyo.c ir_Sharp.c ir_Sony.c ir_Template.c ir_Whynter.c irPronto.c IRremote.c irSend.c
  group HW_Modules/MLX90615
    ../HW_Modules/MLX90615/: Mlx90615.c
  group HW_Modules/NOKIA_5110
    ../HW_Modules/Nokia_5110/: Nokia5110LCD.h NokiaLCD.cpp
  group HW_Modules/SDCard
    ../HW_Modules/SD/src/: diskio.c fat_sd_spi.c ff.c
  group HW_Modules/SSD1306
    ../HW_Modules/Oled/: fonts.c ssd1306.c ssd1306_Test.c
  group HW_Modules/ST77xx
    ../HW_Modules/ST77xx/: ST7735.cpp st7735fonts.c
  group HW_Modules/W25Qxx
    ../HW_Modules/w25qxx/: w25qxx.cpp w25qxx_test.h
  group Startup
    ../Startup/: startup_stm32f103xb.s stm32f1xx_it.c system_stm32f1xx.c
  group SW_Modules/CmdSvr
    ../SW_Modules/CmdSvr/: CmdSvr.c
    ../SW_Modules/CmdSvr/I2C_CMD/: I2C_Commands.c
  group SW_Modules/DebugLog
    ../SW_Modules/DebugLog/: DebugLog.h
  group SW_Modules/Printf
    ../SW_Modules/Printf/: tinyprintf.c
  group SW_Modules/UI
    ../SW_Modules/UI/: Screen.cpp UI.cpp Window.cpp
  group Utils
    ../Utils/inc/: Queue.h
    ../Utils/src/: Utils.c
