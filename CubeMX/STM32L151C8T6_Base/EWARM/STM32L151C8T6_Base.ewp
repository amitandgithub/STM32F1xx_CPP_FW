# IAR project STM32L151C8T6_Base.ewp, settings and files
configuration STM32L151C8T6_Base (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C8 ST STM32L151C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L151xB; USE_FULL_LL_DRIVER; HSE_VALUE=16000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; MSI_VALUE=2097000; HSI_VALUE=16000000; LSI_VALUE=37000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L151C8T6_Base.hex
  ILINK.IlinkOutputFile: STM32L151C8T6_Base.out
  ILINK.IlinkIcfFile: stm32l151xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xb.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_pwr.c stm32l1xx_ll_usart.c stm32l1xx_ll_dma.c
