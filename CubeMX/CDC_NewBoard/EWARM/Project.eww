<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CDC_NewBoard.ewp</path>
  </project>
  <batchBuild />
</workspace>
