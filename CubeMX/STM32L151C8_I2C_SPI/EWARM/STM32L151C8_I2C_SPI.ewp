# IAR project STM32L151C8_I2C_SPI.ewp, settings and files
configuration STM32L151C8_I2C_SPI (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C8 ST STM32L151C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32L151xB; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L151C8_I2C_SPI.hex
  ILINK.IlinkOutputFile: STM32L151C8_I2C_SPI.out
  ILINK.IlinkIcfFile: stm32l151xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xb.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_adc.c stm32l1xx_ll_dma.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_ll_i2c.c stm32l1xx_ll_rtc.c stm32l1xx_ll_spi.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
