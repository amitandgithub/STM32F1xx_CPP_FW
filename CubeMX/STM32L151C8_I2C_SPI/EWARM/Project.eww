<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L151C8_I2C_SPI.ewp</path>
  </project>
  <batchBuild />
</workspace>
