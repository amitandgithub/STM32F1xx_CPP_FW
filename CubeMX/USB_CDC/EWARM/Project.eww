<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USB_CDC.ewp</path>
  </project>
  <batchBuild />
</workspace>
